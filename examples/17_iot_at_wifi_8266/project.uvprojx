# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32l4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32l4xx
  AfterMake: fromelf --bin !L --output rt-thread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32L475xx, RT_USING_ARM_LIBC
  c include: .;applications;packages\at_device-latest;packages\wiznet-v1.0.0\inc;packages\wiznet-v1.0.0\ioLibrary;packages\wiznet-v1.0.0\ioLibrary\Ethernet;packages\wiznet-v1.0.0\ioLibrary\Internet;..\..\rt-thread\include;..\..\rt-thread\libcpu\arm\cortex-m4;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\finsh;..\..\rt-thread\components\libc\compilers\armlibc;..\..\rt-thread\components\libc\compilers\common;..\..\rt-thread\components\net\at\include;..\..\rt-thread\components\net\at\at_socket;..\..\rt-thread\components\net\sal_socket\include;..\..\rt-thread\components\net\sal_socket\include\socket;..\..\rt-thread\components\net\sal_socket\impl;..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket;..\..\rt-thread\components\utilities\logtrace;..\..\drivers;..\..\libraries\CMSIS\Device\ST\STM32L4xx\Include;..\..\libraries\CMSIS\Include;..\..\libraries\STM32L4xx_HAL_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Applications
    applications/: main.c w5500_device.c
  group at_device
    packages/at_device-latest/: at_socket_esp8266.c
  group WIZnet
    packages/wiznet-v1.0.0/src/: wiz_af_inet.c wiz_device.c wiz_socket.c wiz.c wiz_ping.c
    packages/wiznet-v1.0.0/ioLibrary/Ethernet/: wizchip_conf.c wizchip_socket.c
    packages/wiznet-v1.0.0/ioLibrary/Internet/DNS/: wizchip_dns.c
    packages/wiznet-v1.0.0/ioLibrary/Internet/DHCP/: wizchip_dhcp.c
    packages/wiznet-v1.0.0/ioLibrary/Ethernet/W5500/: w5500.c
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/misc/: pin.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c time.c
    ../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group AT
    ../../rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
    ../../rt-thread/components/net/at/at_socket/: at_socket.c
  group SAL
    ../../rt-thread/components/net/sal_socket/src/: sal_ipaddr.c sal_socket.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_at.c
  group Utilities
    ../../rt-thread/components/utilities/logtrace/: log_trace.c
  group Drivers
    ../../drivers/: board.c drv_clock.c drv_gpio.c drv_usart.c drv_spi.c
  group STM32L4xx_HAL_Driver
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    ../../libraries/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_spi.c stm32l4xx_hal_qspi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
software components: CMSIS:CORE 5.0.1
